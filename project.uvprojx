# Keil uVision project project.uvprojx, settings and files
target rtthread (6190000::V6.19::ARMCLANG)
  device: CY8C6248LQI-S2D42:Cortex-M4 Cypress
  pack: Cypress.PSoC6_DFP.1.2.0
  cpu: IRAM(0x08000000,0x80000) IROM(0x10000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: COMPONENT_MW_CORE_MAKE, COMPONENT_MW_SENSOR_MOTION_BMI160, COMPONENT_CAT1, CY8C624ALQI_S2D42, COMPONENT_MW_CY8CKIT_028_TFT, COMPONENT_MW_AUDIO_CODEC_AK4954A, COMPONENT_MW_CMSIS, COMPONENT_GCC_ARM, CY_RTOS_AWARE, COMPONENT_MW_CAPSENSE, CY_SUPPORTS_DEVICE_VALIDATION, __STDC_LIMIT_MACROS, CORE_NAME_CM0P_0, COMPONENT_MW_MTB_PDL_CAT1, COMPONENT_MW_CONNECTIVITY_UTILITIES, COMPONENT_PSOC6_02, COMPONENT_MW_WIFI_CORE_FREERTOS_LWIP_MBEDTLS, COMPONENT_WIFI_INTERFACE_SDIO, COMPONENT_MBEDTLS, CY_USING_PREBUILT_CM0P_IMAGE, COMPONENT_MW_SENSOR_LIGHT, COMPONENT_MW_WPA3_EXTERNAL_SUPPLICANT, COMPONENT_MW_LWIP, COMPONENT_LWIP, COMPONENT_APP_CY8CKIT_062S2_43012, COMPONENT_MW_RETARGET_IO, COMPONENT_43012, COMPONENT_CM4, LWIP_NETIF_REMOVE_CALLBACK=1, COMPONENT_MW_MTB_HAL_CAT1, COMPONENT_MW_CLIB_SUPPORT, TARGET_APP_CY8CKIT_062S2_43012, COMPONENT_MW_HTTP_SERVER, COMPONENT_CAT1A, COMPONENT_MURATA_1LV, COMPONENT_MW_LWIP_NETWORK_INTERFACE_INTEGRATION, CORE_NAME_CM4_0, COMPONENT_MW_BMI160_DRIVER, MAX_NUMBER_OF_HTTP_SERVER_RESOURCES=10, COMPONENT_MW_CORE_LIB, COMPONENT_MW_EMWIN, COMPONENT_MW_RECIPE_MAKE_CAT1A, CY_APPNAME_mtb_example_wifi_web_server, COMPONENT_HCI_UART, COMPONENT_MW_FREERTOS, __RTTHREAD__, CYBSP_WIFI_CAPABLE, CY_USING_HAL, COMPONENT_MW_WIFI_HOST_DRIVER, CY_TARGET_BOARD=APP_CY8CKIT_062S2_43012, COMPONENT_SECURE_SOCKETS, CY_RETARGET_IO_CONVERT_LF_TO_CRLF, COMPONENT_MW_ABSTRACTION_RTOS, COMPONENT_MW_MBEDTLS, COMPONENT_MW_DISPLAY_TFT_ST7789V, RT_USING_ARMLIBC, COMPONENT_CM0P_SLEEP, COMPONENT_MW_WHD_BSP_INTEGRATION, RT_USING_LIBC, COMPONENT_MW_SERIAL_FLASH, COMPONENT_MW_LWIP_FREERTOS_INTEGRATION, COMPONENT_MW_CY_MBEDTLS_ACCELERATION, COMPONENT_MW_SECURE_SOCKETS, MBEDTLS_USER_CONFIG_FILE="mbedtls_user_config.h", __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\libraries\IFX_PSOC6_HAL\mtb_shared\serial-flash;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\src\include;packages\FreeRTOS_Wrapper-latest\FreeRTOS\portable\rt-thread;..\..\..\include;..\libraries\IFX_PSOC6_HAL\psoc6cm0p;..\libraries\IFX_PSOC6_HAL\capsense;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\compilers\common\include;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include;..\..\..\components\drivers\include;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\firmware\COMPONENT_43012;..\..\..\libcpu\arm\common;..\libraries\IFX_PSOC6_HAL\mtb_shared\usbdev;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\nvram;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\firmware;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources;..\..\..\components\net\lwip\lwip-2.0.3\src\include;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\clm;..\libraries\HAL_Drivers\config;..\..\..\components\libc\posix\ipc;..\libraries\IFX_PSOC6_HAL\mtb_shared\csdidac;packages\wlan_cyw43012-v0.0.1;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\inc;packages\wlan_cyw43012-v0.0.1\wifi-host-driver;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\clm\COMPONENT_43012;..\..\..\components\drivers\include;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\src;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\src\bus_protocols;..\..\..\components\drivers\wlan;libs\TARGET_RTT-062S2;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\resource_imp;libs\TARGET_RTT-062S2\config\GeneratedSource;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;..\libraries\IFX_PSOC6_HAL\core-lib\include;..\..\..\components\net\lwip\port;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver;board\ports;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;packages\wlan_cyw43012-v0.0.1\abstraction-rtos\include\COMPONENT_FREERTOS;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\components\net\lwip\lwip-2.0.3\src\include\posix;..\libraries\HAL_Drivers;packages\FreeRTOS_Wrapper-latest\FreeRTOS\include;..\..\..\components\libc\posix\io\eventfd;.;packages\wlan_cyw43012-v0.0.1\abstraction-rtos\include;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1A\include;..\..\..\components\libc\posix\io\epoll;packages\wlan_cyw43012-v0.0.1\whd-bsp-integration;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\COMPONENT_CAT1A\include;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\nvram\COMPONENT_43012;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\cmsis\include;..\..\..\components\libc\compilers\common\extension;packages\wlan_cyw43012-v0.0.1\abstraction-rtos;..\..\..\components\libc\posix\io\stdio;..\libraries\IFX_PSOC6_HAL\retarget-io;board;packages\wlan_cyw43012-v0.0.1\wifi-host-driver\WiFi_Host_Driver\resources\nvram\COMPONENT_43012\COMPONENT_MURATA-1LV;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include_pvt;packages\FreeRTOS_Wrapper-latest\FreeRTOS\include\freertos
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x8000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group cyw43012
    packages/wlan_cyw43012-v0.0.1/wifi-host-driver/WiFi_Host_Driver/src/: whd_logging.c whd_wifi.c whd_clm.c whd_debug.c whd_thread.c whd_sdpcm.c whd_ap.c whd_cdc_bdc.c whd_chip.c whd_management.c whd_buffer_api.c whd_resource_if.c whd_wifi_api.c whd_chip_constants.c whd_network_if.c whd_wifi_p2p.c whd_utils.c whd_events.c
    packages/wlan_cyw43012-v0.0.1/wifi-host-driver/WiFi_Host_Driver/resources/clm/COMPONENT_43012/: 43012C0-mfgtest_clm_blob.c 43012C0_clm_blob.c
    packages/wlan_cyw43012-v0.0.1/wifi-host-driver/WiFi_Host_Driver/src/bus_protocols/: whd_bus.c whd_bus_spi_protocol.c whd_bus_common.c whd_bus_sdio_protocol.c whd_bus_m2m_protocol.c
    packages/wlan_cyw43012-v0.0.1/whd-bsp-integration/COMPONENT_LWIP/: cy_network_buffer_lwip.c
    packages/wlan_cyw43012-v0.0.1/wifi-host-driver/WiFi_Host_Driver/resources/resource_imp/: whd_resources.c
    packages/wlan_cyw43012-v0.0.1/: wifi_ifx_cyw43012.c
    packages/wlan_cyw43012-v0.0.1/wifi-host-driver/WiFi_Host_Driver/resources/firmware/COMPONENT_43012/: 43012C0_bin.c 43012C0-mfgtest_bin.c
    packages/wlan_cyw43012-v0.0.1/whd-bsp-integration/: cybsp_wifi.c
    packages/wlan_cyw43012-v0.0.1/abstraction-rtos/source/: cy_worker_thread.c
    packages/wlan_cyw43012-v0.0.1/abstraction-rtos/source/COMPONENT_FREERTOS/: cyabs_freertos_common.c cyabs_rtos_freertos.c cyabs_rtos_dsram.c cyabs_freertos_helpers.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.S
    board/: board.c
    board/ports/: drv_cyw43012.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh.c shell.c cmd.c
  group FreeRTOS
    packages/FreeRTOS_Wrapper-latest/FreeRTOS/: list.c queue.c tasks.c event_groups.c timers.c
    packages/FreeRTOS_Wrapper-latest/FreeRTOS/portable/rt-thread/: port.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/source/: cyhal_utils.c cyhal_uart.c cyhal_lptimer.c cyhal_gpio.c cyhal_scb_common.c cyhal_clock.c cyhal_utils_impl.c cyhal_syspm.c cyhal_sdhc.c cyhal_interconnect.c cyhal_hwmgr.c cyhal_system.c cyhal_irq_impl.c
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/: cy_ipc_drv.c cy_syspm.c cy_ipc_pipe.c cy_syslib.c cy_scb_uart.c cy_sd_host.c cy_scb_common.c cy_sysclk.c cy_scb_i2c.c cy_gpio.c cy_systick.c cy_sysint.c cy_ipc_sema.c cy_trigmux.c cy_prot.c cy_mcwdt.c
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1A/source/: cy_device.c
    ../libraries/IFX_PSOC6_HAL/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_01_cm0p_sleep.c psoc6_02_cm0p_sleep.c psoc6_03_cm0p_sleep.c psoc6_04_cm0p_sleep.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_02_68_qfn.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_02.c
  group libs
    libs/TARGET_RTT-062S2/: cybsp.c
    libs/TARGET_RTT-062S2/config/GeneratedSource/: cycfg_connectivity_bt.c cycfg_peripherals.c cycfg_qspi_memslot.c cycfg.c cycfg_system.c cycfg_clocks.c cycfg_pins.c cycfg_routing.c cycfg_capsense.c
    libs/TARGET_RTT-062S2/COMPONENT_CM4/: system_psoc6_cm4.c
    libs/TARGET_RTT-062S2/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_psoc6_02_cm4.S
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
